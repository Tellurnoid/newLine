# Repository Tellurnoid/newLine (continued)

## KiCad design KiCad/過去データ/ブロック/LineSensor_Block_prot2/Sides/LineSensor_Block_prot2/LineSensor_Block_prot2.kicad_pcb

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12: LED; LED_0603_1608Metric
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1, J2: Conn_01x09_Socket; PinSocket_1x09_P2.54mm_Horizontal_EDITED
J9, J10, J11, J12: Conn_01x03_Socket; PinHeader_1x03_P2.54mm_Vertical_EDITED
Q1, Q2, Q3, Q4, Q5, Q6, Q7, Q8, Q9, Q10, Q11, Q12: Q_Photo_NPN; LED_0603_1608Metric
R1, R1d1, R2, R2d1, R3, R3d1, R4, R4d1, R5, R5d1, R6, R6d1, R7, R7d1, R8, R8d1, R9, R9d1, R10, R10d1, R11, R11d1, R12, R12d1: R; R_0603_1608Metric

Connections:
3v3_1: J1.2, J9.2, J10.2, R1.1, R2.1, R3.1, R4.1, R5.1, R6.1
3v3_2: J2.2, J11.2, J12.2, R7.1, R8.1, R9.1, R10.1, R11.1, R12.1
GND1: J1.3, J9.1, J10.1, Q1.2 (E), Q2.2 (E), Q3.2 (E), Q4.2 (E), Q5.2 (E), Q6.2 (E), R1d1.2, R2d1.2, R3d1.2, R4d1.2, R5d1.2, R6d1.2
GND2: J2.3, J11.1, J12.1, Q7.2 (E), Q8.2 (E), Q9.2 (E), Q10.2 (E), Q11.2 (E), Q12.2 (E), R7d1.2, R8d1.2, R9d1.2, R10d1.2, R11d1.2, R12d1.2
LED_5V_1: D1.2 (A), D2.2 (A), D3.2 (A), D4.2 (A), D5.2 (A), D6.2 (A), J1.1, J9.3, J10.3
LED_5V_2: D7.2 (A), D8.2 (A), D9.2 (A), D10.2 (A), D11.2 (A), D12.2 (A), J2.1, J11.3, J12.3
unnamed: D1.1 (K), R1d1.1
unnamed: D2.1 (K), R2d1.1
unnamed: D3.1 (K), R3d1.1
unnamed: D4.1 (K), R4d1.1
unnamed: D5.1 (K), R5d1.1
unnamed: D6.1 (K), R6d1.1
unnamed: D7.1 (K), R7d1.1
unnamed: D8.1 (K), R8d1.1
unnamed: D9.1 (K), R9d1.1
unnamed: D10.1 (K), R10d1.1
unnamed: D11.1 (K), R11d1.1
unnamed: D12.1 (K), R12d1.1
unnamed: J1.4, Q1.1 (C), R1.2
unnamed: J1.5, Q2.1 (C), R2.2
unnamed: J1.6, Q3.1 (C), R3.2
unnamed: J1.7, Q4.1 (C), R4.2
unnamed: J1.8, Q5.1 (C), R5.2
unnamed: J1.9, Q6.1 (C), R6.2
unnamed: J2.4, Q7.1 (C), R7.2
unnamed: J2.5, Q8.1 (C), R8.2
unnamed: J2.6, Q9.1 (C), R9.2
unnamed: J2.7, Q10.1 (C), R10.2
unnamed: J2.8, Q11.1 (C), R11.2
unnamed: J2.9, Q12.1 (C), R12.2

Board: 2 copper layers, 88.9 x 88.1 mm, 58 parts (2 on the bottom side), 30 nets.

File KiCad/過去データ/ブロック/LineSensor_Block_prot2/Sides/LineSensor_Block_prot2/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"D1, D10, D11, D12, D2, D3, D4, D5, D6, D7, D8, D9",0603,12,LED,
"J1, J2",PinSocket_1x09_P2.54mm_Horizontal_EDITED,2,Conn_01x09_Socket,
"J10, J11, J12, J9",PinHeader_1x03_P2.54mm_Vertical_EDITED,4,Conn_01x03_Socket,
"Q1, Q10, Q11, Q12, Q2, Q3, Q4, Q5, Q6, Q7, Q8, Q9",0603,12,Q_Photo_NPN,
"R1, R10, R10D1, R11, R11D1, R12, R12D1, R1D1, R2, R2D1, R3, R3D1, R4, R4D1, R5, R5D1, R6, R6D1, R7, R7D1, R8, R8D1, R9, R9D1",0603,24,R,

## KiCad design KiCad/過去データ/全国/Linesensor_Japan_prot2/Linesensor_Japan_prot2.kicad_pcb

Parts:
C1, C2: C; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C3, C4: C; C_Disc_D4.3mm_W1.9mm_P5.00mm
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D34: D_Schottky; D_SOD-323F
H1, H2, H3, H4, H5, H6, H7, H8, H9, H10: MountingHole; MountingHole_3.2mm_M3
J1: Conn_01x04_Socket; JST_XH_S4B-XH-A-1_1x04_P2.50mm_Horizontal
J2: Conn_01x02_Socket; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
J3: Conn_01x09_Socket; PinHeader_1x09_P2.54mm_Horizontal
J4: Conn_01x09_Socket; JST_PH_S9B-PH-K_1x09_P2.00mm_Horizontal
Q1, Q2, Q3, Q4, Q5, Q6, Q7, Q8, Q9, Q10, Q11, Q12, Q13, Q14, Q15, Q16, Q17, Q18, Q19, Q20, Q21, Q22, Q23, Q24, Q25, Q26, Q27, Q28, Q29, Q30, Q31, Q32: Q_Photo_NPN; D_0603_1608Metric_Pad1.05x0.95mm_HandSolder
Q33, Q34: Q_NMOS; TO-251-3-1EP_Horizontal_TabDown_EDITED
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R27, R28, R29, R30, R31, R32, R33, R34, R35, R36, R37, R38, R39, R40, R41, R42, R43, R44, R45, R46, R47, R48, R49, R50, R51, R52, R53, R54, R55, R56, R57, R58, R59, R60, R61, R62, R63, R64: R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R65, R66, R67, R68, R73, R74: R; R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal
U1, U2: CD74HC4067SM; SSOP-24_5.3x8.2mm_P0.65mm
U3: Seeeduino Xiao SAMD

Connections:
3v3: C1.2, C2.2, J3.2, J4.2, R1.1, R2.1, R3.1, R4.1, R5.1, R6.1, R7.1, R8.1, R9.1, R10.1, R11.1, R12.1, R13.1, R14.1, R15.1, R16.1, R17.1, R18.1, R19.1, R20.1, R21.1, R22.1, R23.1, R24.1, R25.1, R26.1, R27.1, R28.1, R29.1, R30.1, R31.1, R32.1, U1.24 (VCC), U2.24 (VCC), U3.12 (3v3)
GND: C1.1, C2.1, C3.2, C4.2, J1.4, J2.2, J3.1, J4.1, Q1.2 (E), Q2.2 (E), Q3.2 (E), Q4.2 (E), Q5.2 (E), Q6.2 (E), Q7.2 (E), Q8.2 (E), Q9.2 (E), Q10.2 (E), Q11.2 (E), Q12.2 (E), Q13.2 (E), Q14.2 (E), Q15.2 (E), Q16.2 (E), Q17.2 (E), Q18.2 (E), Q19.2 (E), Q20.2 (E), Q21.2 (E), Q22.2 (E), Q23.2 (E), Q24.2 (E), Q25.2 (E), Q26.2 (E), Q27.2 (E), Q28.2 (E), Q29.2 (E), Q30.2 (E), Q31.2 (E), Q32.2 (E), Q33.2 (S), Q34.2 (S), R66.2, R74.2, U1.12 (GND), U1.15 (~E), U2.12 (GND), U2.15 (~E), U3.13 (GND)
LED_IO: J3.9, J4.9, R65.1, R73.1, U3.9 (8)
MUX_COM1: C3.1, J3.8, J4.8, U1.1 (COM), U3.1 (0)
MUX_COM2: C4.1, J3.3, J4.3, U2.1 (COM), U3.2 (1)
unnamed: D1.1 (K), R33.1
unnamed: D2.1 (K), R34.1
unnamed: D3.1 (K), R35.1
unnamed: D4.1 (K), R36.1
unnamed: D5.1 (K), R37.1
unnamed: D6.1 (K), R38.1
unnamed: D7.1 (K), R39.1
unnamed: D8.1 (K), R40.1
unnamed: D9.1 (K), R41.1
unnamed: D10.1 (K), R42.1
unnamed: D11.1 (K), R43.1
unnamed: D12.1 (K), R44.1
unnamed: D13.1 (K), R45.1
unnamed: D14.1 (K), R46.1
unnamed: D15.1 (K), R47.1
unnamed: D16.1 (K), R48.1
unnamed: D17.1 (K), R49.1
unnamed: D18.1 (K), R50.1
unnamed: D19.1 (K), R51.1
unnamed: D20.1 (K), R52.1
unnamed: D21.1 (K), R53.1
unnamed: D22.1 (K), R54.1
unnamed: D23.1 (K), R55.1
unnamed: D24.1 (K), R56.1
unnamed: D25.1 (K), R57.1
unnamed: D26.1 (K), R58.1
unnamed: D27.1 (K), R59.1
unnamed: D28.1 (K), R60.1
unnamed: D29.1 (K), R61.1
unnamed: D30.1 (K), R62.1
unnamed: D31.1 (K), R63.1
unnamed: D32.1 (K), R64.1
unnamed: J1.1, U3.7 (6(TX))
unnamed: J1.2, U3.8 ((RX)7)
unnamed: Q1.1 (C), R1.2, U1.20 (I11)
unnamed: Q2.1 (C), R2.2, U1.19 (I12)
unnamed: Q3.1 (C), R3.2, U1.18 (I13)
unnamed: Q4.1 (C), R4.2, U1.17 (I14)
unnamed: Q5.1 (C), R5.2, U1.16 (I15)
unnamed: Q6.1 (C), R6.2, U1.21 (I10)
unnamed: Q7.1 (C), R7.2, U1.22 (I9)
unnamed: Q8.1 (C), R8.2, U1.23 (I8)
unnamed: Q9.1 (C), R9.2, U2.16 (I15)
unnamed: Q10.1 (C), R10.2, U2.17 (I14)
unnamed: Q11.1 (C), R11.2, U2.18 (I13)
unnamed: Q12.1 (C), R12.2, U2.19 (I12)
unnamed: Q13.1 (C), R13.2, U2.23 (I8)
unnamed: Q14.1 (C), R14.2, U2.22 (I9)
unnamed: Q15.1 (C), R15.2, U2.21 (I10)
unnamed: Q16.1 (C), R16.2, U2.20 (I11)
unnamed: Q17.1 (C), R17.2, U2.9 (I0)
unnamed: Q18.1 (C), R18.2, U2.8 (I1)
unnamed: Q19.1 (C), R19.2, U2.7 (I2)
unnamed: Q20.1 (C), R20.2, U2.6 (I3)
unnamed: Q21.1 (C), R21.2, U2.5 (I4)
unnamed: Q22.1 (C), R22.2, U2.4 (I5)
unnamed: Q23.1 (C), R23.2, U2.3 (I6)
unnamed: Q24.1 (C), R24.2, U2.2 (I7)
unnamed: Q25.1 (C), R25.2, U1.6 (I3)
unnamed: Q26.1 (C), R26.2, U1.7 (I2)
unnamed: Q27.1 (C), R27.2, U1.8 (I1)
unnamed: Q28.1 (C), R28.2, U1.9 (I0)
unnamed: Q29.1 (C), R29.2, U1.5 (I4)
unnamed: Q30.1 (C), R30.2, U1.4 (I5)
unnamed: Q31.1 (C), R31.2, U1.3 (I6)
unnamed: Q32.1 (C), R32.2, U1.2 (I7)
unnamed: Q33.3 (D), R33.2, R34.2, R35.2, R36.2, R37.2, R38.2, R39.2, R40.2, R41.2, R42.2, R43.2, R44.2, R45.2, R46.2, R47.2, R48.2, R49.2, R50.2, R51.2, R52.2, R53.2, R54.2, R55.2, R56.2, R57.2, R58.2, R59.2, R60.2, R61.2, R62.2, R63.2, R64.2
unnamed: Q33.1 (G), R73.2, R74.1
unnamed: Q34.1 (G), R65.2, R66.1
unnamed: Q34.3 (D), R67.1, R68.1
unnamed: R67.2, R68.2
S0: J3.7, J4.7, U1.10 (S0), U2.10 (S0), U3.3 (2)
S1: J3.6, J4.6, U1.11 (S1), U2.11 (S1), U3.4 (3)
S2: J3.5, J4.5, U1.14 (S2), U2.14 (S2), U3.5 (4)
S3: J3.4, J4.4, U1.13 (S3), U2.13 (S3), U3.6 (5)
VCC: J1.3, U3.14 ((5V)VCC)

Notes on the sheet:
A,+（Anode)
10kΩ
K,-(Cathode)
100Ω
100pF
※フットプリントのピン配置要確認
22Ω
MOSFET中央の穴 Drain =LED K
SeeedのD0/A0のみDAC、他1~10はPWM
※抵抗値自信なし。要確認
１００ｋ
0.1uF
22Ω(なくてもOK)

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
Board: 2 copper layers, 140.0 x 140.0 mm, 145 parts (7 on the bottom side), 79 nets.

File KiCad/過去データ/全国/Linesensor_Japan_prot2/production/1/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C2",0603,2,C,
"C3, C4",C_Disc_D4.3mm_W1.9mm_P5.00mm,2,C,
"D1, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D2, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D3, D30, D31, D32, D4, D5, D6, D7, D8, D9",0603,32,LED,
J1,JST_XH_S4B-XH-A-1_1x04_P2.50mm_Horizontal,1,Conn_01x04_Socket,
J2,JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal,1,Conn_01x02_Socket,
J3,PinHeader_1x09_P2.54mm_Horizontal,1,Conn_01x09_Socket,
J4,JST_XH_S9B-XH-A-1_1x09_P2.50mm_Horizontal,1,Conn_01x09_Socket,
"Q1, Q10, Q11, Q12, Q13, Q14, Q15, Q16, Q17, Q18, Q19, Q2, Q20, Q21, Q22, Q23, Q24, Q25, Q26, Q27, Q28, Q29, Q3, Q30, Q31, Q32, Q4, Q5, Q6, Q7, Q8, Q9",0603,32,Q_Photo_NPN,
Q33,TO-251-3-1EP_Horizontal_TabDown_EDITED,1,Q_NMOS,
"R1, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R2, R20, R21, R22, R23, R24, R25, R26, R27, R28, R29, R3, R30, R31, R32, R33, R34, R35, R36, R37, R38, R39, R4, R40, R41, R42, R43, R44, R45, R46, R47, R48, R49, R5, R50, R51, R52, R53, R54, R55, R56, R57, R58, R59, R6, R60, R61, R62, R63, R64, R7, R8, R9",0603,64,R,
"R73, R74",R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal,2,R,
"U1, U2",SSOP-24_5.3x8.2mm_P0.65mm,2,CD74HC4067SM,
U3,Seeeduino Xiao SAMD,1,~,
