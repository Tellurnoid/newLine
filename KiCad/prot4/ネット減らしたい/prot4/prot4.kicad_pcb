# Repository Tellurnoid/newLine

## KiCad design KiCad/prot4/ネット減らしたい/prot4/prot4.kicad_pcb

Schematic: prot4.kicad_sch

Parts:
B1, B2: R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C18, C19, C20, C21, C22, C25, C26: C; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C24: C; C_Rect_L7.0mm_W2.0mm_P5.00mm
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D33: D_Schottky; D_SOD-323_HandSoldering
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1: Conn_01x02_Socket; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
J2: LED_SW; PinHeader_1x03_P2.54mm_Vertical
J3: Conn_01x04_Socket; JST_PH_S4B-PH-K_1x04_P2.00mm_Horizontal
LS1: Speaker_Crystal; PinHeader_1x02_P2.54mm_Vertical
Q1, Q2, Q3, Q4, Q5, Q6, Q7, Q8, Q9, Q10, Q11, Q12, Q13, Q14, Q15, Q16, Q17, Q18, Q19, Q20, Q21, Q22, Q23, Q24, Q25, Q26, Q27, Q28, Q29, Q30, Q31, Q32: Q_Photo_NPN; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R1: R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
RP2040_Zero1, RP2040_Zero2: RP2040_zero_kimoi3
RV1: R_Potentiometer_Trim; hankotei_node
Rca1, Rca2, Rca3, Rca4, Rca5, Rca6, Rca7, Rca8, Rca9, Rca10, Rca11, Rca12, Rca13, Rca14, Rca15, Rca16: R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
Rcb1, Rcb2, Rcb3, Rcb4, Rcb5, Rcb6, Rcb7, Rcb8, Rcb9, Rcb10, Rcb11, Rcb12, Rcb13, Rcb14, Rcb15, Rcb16: R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
Rl1, Rl2, Rl3, Rl4, Rl5, Rl6, Rl7, Rl8, Rl9, Rl10, Rl11, Rl12, Rl13, Rl14, Rl15, Rl16, Rl17, Rl18, Rl19, Rl20, Rl21, Rl22, Rl23, Rl24, Rl25, Rl26, Rl27, Rl28, Rl29, Rl30, Rl31, Rl32: R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
Rsa1, Rsa2, Rsa3, Rsa4, Rsa5, Rsa6, Rsa7, Rsa8, Rsa9, Rsa10, Rsa11, Rsa12, Rsa13, Rsa14, Rsa15, Rsa16: R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
Rsb1, Rsb2, Rsb3, Rsb4, Rsb5, Rsb6, Rsb7, Rsb8, Rsb9, Rsb10, Rsb11, Rsb12, Rsb13, Rsb14, Rsb15, Rsb16: R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U1, U2, U3, U4, U5, U6, U7, U8, U9, U10, U11, U12, U13, U14, U15, U16: LM393; LM393_SOIC-8_3.9x4.9mm_P1.27mm_handhandsoilder

Connections:
1: RP2040_Zero1., RP2040_Zero1.8 (7), Rca1.1, U1.1
2: RP2040_Zero1.9 (8), Rcb1.1, U1.7
3: RP2040_Zero2.15 (14), Rca2.1, U2.1
4: RP2040_Zero2.16 (15), Rcb2.1, U2.7
5: RP2040_Zero2.17 (26), Rca3.1, U3.1
6: RP2040_Zero2.18 (27), Rcb3.1, U3.7
7: RP2040_Zero2.10 (9), Rca4.1, U4.1
8: RP2040_Zero2.11 (10), Rcb4.1, U4.7
9: RP2040_Zero2.2 (1), Rca5.1, U5.1
10: RP2040_Zero2.1 (0), Rcb5.1, U5.7
11: RP2040_Zero2.12 (11), Rca6.1, U6.1
12: RP2040_Zero2.14 (13), Rcb6.1, U6.7
13: RP2040_Zero2.13 (12), Rca7.1, U7.1
14: RP2040_Zero2.9 (8), Rcb7.1, U7.7
15: RP2040_Zero2.5 (4), Rca8.1, U8.1
17: RP2040_Zero2.4 (3), Rca9.1, U9.1
18: RP2040_Zero2.7 (6), Rcb9.1, U9.7
19: RP2040_Zero2.3 (2), Rca10.1, U10.1
20: RP2040_Zero2.6 (5), Rcb10.1, U10.7
21: RP2040_Zero1.17 (26), Rca11.1, U11.1
22: RP2040_Zero1.16 (15), Rcb11.1, U11.7
23: RP2040_Zero1.15 (14), Rca12.1, U12.1
24: RP2040_Zero1.10 (9), Rcb12.1, U12.7
25: RP2040_Zero1.4 (3), Rca13.1, U13.1
26: RP2040_Zero1.11 (10), Rcb13.1, U13.7
27: RP2040_Zero1.14 (13), Rca14.1, U14.1
28: RP2040_Zero1.5 (4), Rcb14.1, U14.7
29: RP2040_Zero1.12 (11), Rca15.1, U15.1
30: RP2040_Zero1.13 (12), Rcb15.1, U15.7
31: RP2040_Zero1.6 (5), Rca16.1, U16.1
32: RP2040_Zero1.7 (6), Rcb16.1, U16.7
Conp_PWM: R1.1, RP2040_Zero1.3 (2)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C24.2, C25.2, C26.2, J1.2, J3.4, LS1.2, RP2040_Zero1.22 (GND), RP2040_Zero2.22 (GND), RV1.3, Rl1.2, Rl2.2, Rl3.2, Rl4.2, Rl5.2, Rl6.2, Rl7.2, Rl8.2, Rl9.2, Rl10.2, Rl11.2, Rl12.2, Rl13.2, Rl14.2, Rl15.2, Rl16.2, Rl17.2, Rl18.2, Rl19.2, Rl20.2, Rl21.2, Rl22.2, Rl23.2, Rl24.2, Rl25.2, Rl26.2, Rl27.2, Rl28.2, Rl29.2, Rl30.2, Rl31.2, Rl32.2, Rsa1.1, Rsa2.1, Rsa3.1, Rsa4.1, Rsa5.1, Rsa6.1, Rsa7.1, Rsa8.1, Rsa9.1, Rsa10.1, Rsa11.1, Rsa12.1, Rsa13.1, Rsa14.1, Rsa15.1, Rsa16.1, Rsb1.1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
IMU_5V: C17.1, C18.1, C19.1, C20.1, D33.1 (K), RP2040_Zero1.23 (5V), RP2040_Zero2.23 (5V)
LED_5V: D1.2 (A), D2.2 (A), D3.2 (A), D4.2 (A), D5.2 (A), D6.2 (A), D7.2 (A), D8.2 (A), D9.2 (A), D10.2 (A), D11.2 (A), D12.2 (A), D13.2 (A), D14.2 (A), D15.2 (A), D16.2 (A), D17.2 (A), D18.2 (A), D19.2 (A), D20.2 (A), D21.2 (A), D22.2 (A), D23.2 (A), D24.2 (A), D25.2 (A), D26.2 (A), D27.2 (A), D28.2 (A), D29.2 (A), D30.2 (A), D31.2 (A), D32.2 (A), J2.1
unnamed 35: B1.1, C24.1, R1.2; also elsewhere on the board
unnamed: B2.1, RV1.2
unnamed: D1.1 (K), Rl1.1
unnamed: D2.1 (K), Rl2.1
unnamed: D3.1 (K), Rl3.1
unnamed: D4.1 (K), Rl4.1
unnamed: D5.1 (K), Rl5.1
unnamed: D6.1 (K), Rl6.1
unnamed: D7.1 (K), Rl7.1
unnamed: D8.1 (K), Rl8.1
unnamed: D9.1 (K), Rl9.1
unnamed: D10.1 (K), Rl10.1
unnamed: D11.1 (K), Rl11.1
unnamed: D12.1 (K), Rl12.1
unnamed: D13.1 (K), Rl13.1
unnamed: D14.1 (K), Rl14.1
unnamed: D15.1 (K), Rl15.1
unnamed: D16.1 (K), Rl16.1
unnamed: D17.1 (K), Rl17.1
unnamed: D18.1 (K), Rl18.1
unnamed: D19.1 (K), Rl19.1
unnamed: D20.1 (K), Rl20.1
unnamed: D21.1 (K), Rl21.1
unnamed: D22.1 (K), Rl22.1
unnamed: D23.1 (K), Rl23.1
unnamed: D24.1 (K), Rl24.1
unnamed: D25.1 (K), Rl25.1
unnamed: D26.1 (K), Rl26.1
unnamed: D27.1 (K), Rl27.1
unnamed: D28.1 (K), Rl28.1
unnamed: D29.1 (K), Rl29.1
unnamed: D30.1 (K), Rl30.1
unnamed: D31.1 (K), Rl31.1
unnamed: D32.1 (K), Rl32.1
unnamed: D33.2 (A), J3.3
unnamed: C21.1, C22.1, J1.1, J2.2, J2.3
unnamed: Q1.2 (E), Rsa1.2, U1.2 (-)
unnamed: Q2.2 (E), Rsb1.2, U1.6 (-)
unnamed: Q3.2 (E), Rsa2.2, U2.2 (-)
unnamed: Q4.2 (E), Rsb2.2, U2.6 (-)
unnamed: Q5.2 (E), Rsa3.2, U3.2 (-)
unnamed: Q6.2 (E), Rsb3.2, U3.6 (-)
unnamed: Q7.2 (E), Rsa4.2, U4.2 (-)
unnamed: Q8.2 (E), Rsb4.2, U4.6 (-)
unnamed: Q9.2 (E), Rsa5.2, U5.2 (-)
unnamed: Q10.2 (E), Rsb5.2, U5.6 (-)
unnamed: Q11.2 (E), Rsa6.2, U6.2 (-)
unnamed: Q12.2 (E), Rsb6.2, U6.6 (-)
unnamed: Q13.2 (E), Rsa7.2, U7.2 (-)
unnamed: Q14.2 (E), Rsb7.2, U7.6 (-)
unnamed: Q15.2 (E), Rsa8.2, U8.2 (-)
unnamed: Q16.2 (E), Rsb8.2, U8.6 (-)
unnamed: Q17.2 (E), Rsa9.2, U9.2 (-)
unnamed: Q18.2 (E), Rsb9.2, U9.6 (-)
unnamed: Q19.2 (E), Rsa10.2, U10.2 (-)
unnamed: Q20.2 (E), Rsb10.2, U10.6 (-)
unnamed: Q21.2 (E), Rsa11.2, U11.2 (-)
unnamed: Q22.2 (E), Rsb11.2, U11.6 (-)
unnamed: Q23.2 (E), Rsa12.2, U12.2 (-)
unnamed: Q24.2 (E), Rsb12.2, U12.6 (-)
unnamed: Q25.2 (E), Rsa13.2, U13.2 (-)
unnamed: Q26.2 (E), Rsb13.2, U13.6 (-)
unnamed: Q27.2 (E), Rsa14.2, U14.2 (-)
unnamed: Q28.2 (E), Rsb14.2, U14.6 (-)
unnamed: Q29.2 (E), Rsa15.2, U15.2 (-)
unnamed: Q30.2 (E), Rsb15.2, U15.6 (-)
unnamed: Q31.2 (E), Rsa16.2, U16.2 (-)
unnamed: Q32.2 (E), Rsb16.2, U16.6 (-)
unnamed: LS1.1, RP2040_Zero1.18 (27)
OUT_RX: J3.2, RP2040_Zero1.20 (29)
OUT_TX: J3.1, RP2040_Zero1.19 (28)
RP1_RX: RP2040_Zero1.2 (1), RP2040_Zero2.19 (28)
RP1_TX: RP2040_Zero1.1 (0), RP2040_Zero2.20 (29)
VCC: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C25.1, C26.1, Q1.1 (C), Q2.1 (C), Q3.1 (C), Q4.1 (C), Q5.1 (C), Q6.1 (C), Q7.1 (C), Q8.1 (C), Q9.1 (C), Q10.1 (C), Q11.1 (C), Q12.1 (C), Q13.1 (C), Q14.1 (C), Q15.1 (C), Q16.1 (C), Q17.1 (C), Q18.1 (C), Q19.1 (C), Q20.1 (C), Q21.1 (C), Q22.1 (C), Q23.1 (C), Q24.1 (C), Q25.1 (C), Q26.1 (C), Q27.1 (C), Q28.1 (C), Q29.1 (C), Q30.1 (C), Q31.1 (C), Q32.1 (C), RP2040_Zero1.21 (3V3), RP2040_Zero2.21 (3V3), RV1.1, Rca1.2, Rca2.2, Rca3.2, Rca4.2, Rca5.2, Rca6.2, Rca7.2, Rca8.2, Rca9.2, Rca10.2, Rca11.2, Rca12.2, Rca13.2, Rca14.2, Rca15.2, Rca16.2, Rcb1.2, Rcb2.2, Rcb3.2, Rcb4.2, Rcb5.2, Rcb6.2, Rcb7.2, Rcb8.2, Rcb9.2, Rcb10.2, Rcb11.2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; also elsewhere on the board
conp_+: B1.2, B2.2, U1.3 (+), U1.5 (+), U2.3 (+), U2.5 (+), U3.3 (+), U3.5 (+), U4.3 (+), U4.5 (+), U5.3 (+), U5.5 (+), U6.3 (+), U6.5 (+), U7.3 (+), U7.5 (+), U8.3 (+), U8.5 (+), U9.3 (+), U9.5 (+), U10.3 (+), U10.5 (+), U11.3 (+), U11.5 (+), U12.3 (+), U12.5 (+), U13.3 (+), U13.5 (+), U14.3 (+), U14.5 (+), U15.3 (+), U15.5 (+), U16.3 (+), U16.5 (+)

Notes on the sheet:
10nF?
LED_POWER
UART ハードウェアシリアルなら UART0 (TX,RX)=(0,1)(TX12,16,28)(RX13,17,29) UART1 (TX,RX)=(4,5)(TX8,20,24)(RX9,21,25)
とりあえず10ｋΩ1608
UART
Bridge
注意：VCCは3.3V

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
Board: 2 copper layers, 140.0 x 140.0 mm, 217 parts (2 on the bottom side), 111 nets.

Other parts of the board:
C23: C; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder

Their connections:
unnamed 35: C23.2; also elsewhere on the board
VCC: C23.1; also elsewhere on the board

File KiCad/prot4/ネット減らしたい/prot4(カクカク配線修正前)/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"B1, B2, R1, RCA1, RCA10, RCA11, RCA12, RCA13, RCA14, RCA15, RCA16, RCA2, RCA3, RCA4, RCA5, RCA6, RCA7, RCA8, RCA9, RCB1, RCB10, RCB11, RCB12, RCB13, RCB14, RCB15, RCB16, RCB2, RCB3, RCB4, RCB5, RCB6, RCB7, RCB8, RCB9, RL1, RL10, RL11, RL12, RL13, RL14, RL15, RL16, RL17, RL18, RL19, RL2, RL20, RL21, RL22, RL23, RL24, RL25, RL26, RL27, RL28, RL29, RL3, RL30, RL31, RL32, RL4, RL5, RL6, RL7, RL8, RL9, RSA1, RSA10, RSA11, RSA12, RSA13, RSA14, RSA15, RSA16, RSA2, RSA3, RSA4, RSA5, RSA6, RSA7, RSA8, RSA9, RSB1, RSB10, RSB11, RSB12, RSB13, RSB14, RSB15, RSB16, RSB2, RSB3, RSB4, RSB5, RSB6, RSB7, RSB8, RSB9",0603,99,R,
"C1, C10, C11, C12, C13, C14, C15, C16, C17, C18, C19, C2, C20, C21, C22, C23, C25, C26, C3, C4, C5, C6, C7, C8, C9",0603,25,C,
C24,C_Rect_L7.0mm_W2.0mm_P5.00mm,1,C,
"D1, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D2, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D3, D30, D31, D32, D4, D5, D6, D7, D8, D9",0603,32,LED,
D33,D_SOD-323_HandSoldering,1,D_Schottky,
J1,JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal,1,Conn_01x02_Socket,
J2,PinHeader_1x03_P2.54mm_Vertical,1,LED_SW,
J3,JST_PH_S4B-PH-K_1x04_P2.00mm_Horizontal,1,Conn_01x04_Socket,
LS1,PinHeader_1x02_P2.54mm_Vertical,1,Speaker_Crystal,
"Q1, Q10, Q11, Q12, Q13, Q14, Q15, Q16, Q17, Q18, Q19, Q2, Q20, Q21, Q22, Q23, Q24, Q25, Q26, Q27, Q28, Q29, Q3, Q30, Q31, Q32, Q4, Q5, Q6, Q7, Q8, Q9",0603,32,Q_Photo_NPN,
"RP2040_ZERO1, RP2040_ZERO2",RP2040_zero_kimoi3,2,~,
RV1,hankotei_node,1,R_Potentiometer_Trim,
"U1, U10, U11, U12, U13, U14, U15, U16, U2, U3, U4, U5, U6, U7, U8, U9",LM393_SOIC-8_3.9x4.9mm_P1.27mm_handhandsoilder,16,LM393,

## KiCad design KiCad/prot3/prot3基盤外形まで/prot3.kicad_pcb

Board: 2 copper layers, 140.0 x 140.0 mm, 129 parts (0 on the bottom side), 73 nets, no tracks yet.

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10: C; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C11: C_Polarized_Small_US; SOIC-14_3.9x8.7mm_P1.27mm
C12, C13: C_Polarized_Small_US; C_Radial_D8.0mm_H11.5mm_P3.50mm
D33: D_Schottky; D_SOD-323_HandSoldering
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1: Conn_01x02_Socket; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
J2: LED_SW; PinHeader_1x03_P2.54mm_Vertical
J3: Conn_01x04_Socket; JST_PH_S4B-PH-K_1x04_P2.00mm_Horizontal
LS1: Speaker_Crystal; Buzzer_TDK_PS1240P02BT_D12.2mm_H6.5mm
RP2040_Zero1, RP2040_Zero2: RP2040_zero
RV1: R_Potentiometer_Trim; hankotei_node
Rc1, Rc2, Rc3, Rc4, Rc5, Rc6, Rc7, Rc8, Rc9, Rc10, Rc11, Rc12, Rc13, Rc14, Rc15, Rc16, Rc17, Rc18, Rc19, Rc20, Rc21, Rc22, Rc23, Rc24, Rc25, Rc26, Rc27, Rc28, Rc29, Rc30, Rc31, Rc32: R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
Rl1, Rl2, Rl3, Rl4, Rl5, Rl6, Rl7, Rl8, Rl9, Rl10, Rl11, Rl12, Rl13, Rl14, Rl15, Rl16, Rl17, Rl18, Rl19, Rl20, Rl21, Rl22, Rl23, Rl24, Rl25, Rl26, Rl27, Rl28, Rl29, Rl30, Rl31, Rl32: R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
Rs1, Rs2, Rs3, Rs4, Rs5, Rs6, Rs7, Rs8, Rs9, Rs10, Rs11, Rs12, Rs13, Rs14, Rs15, Rs16, Rs17, Rs18, Rs19, Rs20, Rs21, Rs22, Rs23, Rs24, Rs25, Rs26, Rs27, Rs28, Rs29, Rs30, Rs31, Rs32: R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U1, U2, U3, U4, U5, U6, U7, U8: LM339; SOIC-14_3.9x8.7mm_P1.27mm

Connections:
1: Rc1.2, U1.2
2: Rc2.2, U1.1
3: Rc3.2, U1.13
4: Rc4.2, U1.14
5: Rc5.2, U2.2
6: Rc6.2, U2.1
7: Rc7.2, U2.13
8: Rc8.2, U2.14
9: Rc9.2, U3.2
10: Rc10.2, U3.1
11: Rc11.2, U3.13
12: Rc12.2, U3.14
13: Rc13.2, U4.2
14: Rc14.2, U4.1
15: Rc15.2, U4.13
16: Rc16.2, U4.14
17: Rc17.2, U5.2
18: Rc18.2, U5.1
19: Rc19.2, U5.13
20: Rc20.2, U5.14
21: Rc21.2, U6.2
22: Rc22.2, U6.1
23: Rc23.2, U6.13
24: Rc24.2, U6.14
25: Rc25.2, U7.2
26: Rc26.2, U7.1
27: Rc27.2, U7.13
28: Rc28.2, U7.14
29: Rc29.2, U8.2
30: Rc30.2, U8.1
31: Rc31.2, U8.13
32: Rc32.2, U8.14
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, J1.2, J3.4, RP2040_Zero1.22 (GND), RP2040_Zero2.22 (GND), RV1.3, Rl1.2, Rl2.2, Rl3.2, Rl4.2, Rl5.2, Rl6.2, Rl7.2, Rl8.2, Rl9.2, Rl10.2, Rl11.2, Rl12.2, Rl13.2, Rl14.2, Rl15.2, Rl16.2, Rl17.2, Rl18.2, Rl19.2, Rl20.2, Rl21.2, Rl22.2, Rl23.2, Rl24.2, Rl25.2, Rl26.2, Rl27.2, Rl28.2, Rl29.2, Rl30.2, Rl31.2, Rl32.2, Rs1.2, Rs2.2, Rs3.2, Rs4.2, Rs5.2, Rs6.2, Rs7.2, Rs8.2, Rs9.2, Rs10.2, Rs11.2, Rs12.2, Rs13.2, Rs14.2, Rs15.2, Rs16.2, Rs17.2, Rs18.2, Rs19.2, Rs20.2, Rs21.2, Rs22.2, Rs23.2, Rs24.2, Rs25.2, Rs26.2, Rs27.2, Rs28.2, Rs29.2, Rs30.2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
IMU_5V: C9.1, C10.1, C11.1, C12.1, D33.1 (K), RP2040_Zero1.23 (5V), RP2040_Zero2.23 (5V)
LED_5V: C13.1, J1.1, J2.3
unnamed: D33.2 (A), J3.3
unnamed: J2.1, J2.2
unnamed: Rs1.1, U1.4 (-)
unnamed: Rs2.1, U1.6 (-)
unnamed: Rs3.1, U1.10 (-)
unnamed: Rs4.1, U1.8 (-)
unnamed: Rs5.1, U2.4 (-)
unnamed: Rs6.1, U2.6 (-)
unnamed: Rs7.1, U2.10 (-)
unnamed: Rs8.1, U2.8 (-)
unnamed: Rs9.1, U3.4 (-)
unnamed: Rs10.1, U3.6 (-)
unnamed: Rs11.1, U3.10 (-)
unnamed: Rs12.1, U3.8 (-)
unnamed: Rs13.1, U4.4 (-)
unnamed: Rs14.1, U4.6 (-)
unnamed: Rs15.1, U4.10 (-)
unnamed: Rs16.1, U4.8 (-)
unnamed: Rs17.1, U5.4 (-)
unnamed: Rs18.1, U6.4 (-)
unnamed: Rs19.1, U7.4 (-)
unnamed: Rs20.1, U8.4 (-)
unnamed: Rs21.1, U5.6 (-)
unnamed: Rs22.1, U6.6 (-)
unnamed: Rs23.1, U7.6 (-)
unnamed: Rs24.1, U8.6 (-)
unnamed: Rs25.1, U5.10 (-)
unnamed: Rs26.1, U6.10 (-)
unnamed: Rs27.1, U7.10 (-)
unnamed: Rs28.1, U8.10 (-)
unnamed: Rs29.1, U5.8 (-)
unnamed: Rs30.1, U6.8 (-)
unnamed: Rs31.1, U7.8 (-)
unnamed: Rs32.1, U8.8 (-)
OUT_RX: J3.2, RP2040_Zero1.2 (1)
OUT_TX: J3.1, RP2040_Zero1.1 (0)
VCC: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, RP2040_Zero1.21 (3V3), RP2040_Zero2.21 (3V3), RV1.1, Rc1.1, Rc2.1, Rc3.1, Rc4.1, Rc5.1, Rc6.1, Rc7.1, Rc8.1, Rc9.1, Rc10.1, Rc11.1, Rc12.1, Rc13.1, Rc14.1, Rc15.1, Rc16.1, Rc17.1, Rc18.1, Rc19.1, Rc20.1, Rc21.1, Rc22.1, Rc23.1, Rc24.1, Rc25.1, Rc26.1, Rc27.1, Rc28.1, Rc29.1, Rc30.1, Rc31.1, Rc32.1, U1.3 (V+), U2.3 (V+), U3.3 (V+), U4.3 (V+), U5.3 (V+), U6.3 (V+), U7.3 (V+), U8.3 (V+)
conp_+: RV1.2, U1.5 (+), U1.7 (+), U1.9 (+), U1.11 (+), U2.5 (+), U2.7 (+), U2.9 (+), U2.11 (+), U3.5 (+), U3.7 (+), U3.9 (+), U3.11 (+), U4.5 (+), U4.7 (+), U4.9 (+), U4.11 (+), U5.5 (+), U5.7 (+), U5.9 (+), U5.11 (+), U6.5 (+), U6.7 (+), U6.9 (+), U6.11 (+), U7.5 (+), U7.7 (+), U7.9 (+), U7.11 (+), U8.5 (+), U8.7 (+), U8.9 (+), U8.11 (+)

## KiCad design KiCad/cf/EchoBoard/EchoBoard/EchoBoard.kicad_pcb

Parts:
C1: C; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C2: C_Polarized_US; C_Radial_D8.0mm_H11.5mm_P3.50mm
D1: D_Schottky; D_SOD-323_HandSoldering
Echo_R1, Echo_R2, Echo_R3, Echo_R4, Echo_R5, Echo_R6, Echo_R7, Echo_R8: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
HC-SR1, HC-SR2, HC-SR3, HC-SR4, HC-SR5, HC-SR6, HC-SR7, HC-SR8: HC-SR04
LS1: Speaker_Crystal; Buzzer_TDK_PS1240P02BT_D12.2mm_H6.5mm
R1: R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
RP2040_Zero1: 名称未設定
SSD1: SSD1306
SW1, SW2, SW3, SW4: SW_Push; SW_PUSH-12mm_Wuerth-430476085716
toMain1: Conn_01x04_Socket; JST_PH_S4B-PH-K_1x04_P2.00mm_Horizontal

Connections:
+3V3: HC-SR1.4 (Vcc), HC-SR2.4 (Vcc), HC-SR3.4 (Vcc), HC-SR4.4 (Vcc), HC-SR5.4 (Vcc), HC-SR6.4 (Vcc), HC-SR7.4 (Vcc), HC-SR8.4 (Vcc), RP2040_Zero1.21 (3V3), SSD1.2 (VCC)
Echo_1: Echo_R1.1, HC-SR1.3 (Trig), RP2040_Zero1.9 (8)
Echo_2: Echo_R2.1, HC-SR2.3 (Trig), RP2040_Zero1.16 (15)
Echo_3: Echo_R3.1, HC-SR3.3 (Trig), RP2040_Zero1.14 (13)
Echo_4: Echo_R4.1, HC-SR4.3 (Trig), RP2040_Zero1.15 (14)
Echo_5: Echo_R5.1, HC-SR5.3 (Trig), RP2040_Zero1.13 (12)
Echo_6: Echo_R6.1, HC-SR6.3 (Trig), RP2040_Zero1.12 (11)
Echo_7: Echo_R7.1, HC-SR7.3 (Trig), RP2040_Zero1.11 (10)
Echo_8: Echo_R8.1, HC-SR8.3 (Trig), RP2040_Zero1.10 (9)
GND: C1.1, C2.2, HC-SR1.1 (GND), HC-SR2.1 (GND), HC-SR3.1 (GND), HC-SR4.1 (GND), HC-SR5.1 (GND), HC-SR6.1 (GND), HC-SR7.1 (GND), HC-SR8.1 (GND), LS1.2, RP2040_Zero1.22 (GND), SSD1.1 (GND), SW1.2, SW2.2, SW3.2, SW4.2, toMain1.4
unnamed: C1.2, C2.1, D1.1 (K), RP2040_Zero1.23 (5V)
unnamed: Echo_R1.2, HC-SR1.2 (Echo)
unnamed: Echo_R2.2, HC-SR2.2 (Echo)
unnamed: Echo_R3.2, HC-SR3.2 (Echo)
unnamed: Echo_R4.2, HC-SR4.2 (Echo)
unnamed: Echo_R5.2, HC-SR5.2 (Echo)
unnamed: Echo_R6.2, HC-SR6.2 (Echo)
unnamed: Echo_R7.2, HC-SR7.2 (Echo)
unnamed: Echo_R8.2, HC-SR8.2 (Echo)
unnamed: LS1.1, R1.2
unnamed: RP2040_Zero1.1 (0), toMain1.1
unnamed: RP2040_Zero1.2 (1), toMain1.2
unnamed: RP2040_Zero1.3 (2), SW1.1
unnamed: RP2040_Zero1.4 (3), SW2.1
unnamed: RP2040_Zero1.7 (6), SW3.1
unnamed: RP2040_Zero1., RP2040_Zero1.8 (7), SW4.1
unnamed: R1.1, RP2040_Zero1.18 (27)
SCL: RP2040_Zero1.6 (5), SSD1.3 (SCL)
SDA: RP2040_Zero1.5 (4), SSD1.4 (SDA)
VCC: D1.2 (A), toMain1.3

Board: 2 copper layers, 100.0 x 100.0 mm, 28 parts (8 on the bottom side), 30 nets.
